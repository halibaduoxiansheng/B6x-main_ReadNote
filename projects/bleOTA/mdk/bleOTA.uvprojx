# Keil uVision project bleOTA.uvprojx, settings and files
target bleOTA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: B6x Generic
  pack: Generic.B6x.1.0.0
  cpu: CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: bleOTA +hex
  AfterMake: powershell -executionpolicy Unrestricted -file .\link_high_bank.PS1
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 --thumb --gnu --bss_threshold=0 --preinclude=..\src\cfg.h
  c include: ..\src;..\..\..\core;..\..\..\core\reg;..\..\..\drivers\api;..\..\..\modules\api;..\..\..\ble\api;..\..\..\ble\app;..\..\..\ble\prf
  asm misc: --thumb
  library: MicroLIB
  scatter file: ..\src\link_xip_ble_0x04000.sct
  link misc: --diag_suppress=L6312,L6314,L6329
  group core
    ../../../core/mdk/: startup.s
  group src
    ../src/: cfg.h main.c myapp.c proc.c ota.c
  group drivers
    ../../../drivers/api/: drvs.h
    ../../../drivers/lib/: drvs.lib
  group modules
    ../../../modules/src/: uart1Rb.c leds.c sftmr.c
  group ble\app
    ../../../ble/app/: app.c app_msg.c app_gapm.c app_gapc.c
    ../src/: app_actv.c
  group ble\prf
    ../../../ble/prf/: prf_diss.c prf_sess.c prf_otas.c
  group ble\lib
    ../../../ble/lib/: ble6.lib
  group debug
    ../../../modules/src/: debug.c
